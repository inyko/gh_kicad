# Repository inyko/gh_kicad

## KiCad design q20/main.kicad_pcb

Parts:
C1, C2, C3, C4: 104
C5: 10uF
C6, C7: 10p
J1: USB_B
P1: CONN_4
R1: 10K
R2: 1.5K
SW1: UP
SW2: DOWN
SW3: LEFT
SW4: RIGHT
SW5: A
SW6: B
SW7: RST
SW8: X
SW9: Y
SW10: L
SW11: R
SW12: SELECT
SW13: START
SW14: BK1
SW15: BK2
SW16: BK3
SW17: BK4
U1: STM32F103_48PIN
U2: AMS1117-3.3
Y1: 8MHz

Connections:
+3.3V: C1.1, C2.1, C3.1, C4.1, P1.4, R1.1, U1.8 (VSSA), U1.23 (VSS_1), U1.35 (VSS_2), U1.47 (VSS_3), U2.2 (OUT)
+5V: J1.1 (VBUS), R2.1, U2.3 (IN)
A: SW5.1 (A), U1.42 (PB6)
B: SW6.1 (A), U1.41 (PB5)
BK1: SW14.1 (A), U1.40 (PB4)
BK2: SW15.1 (A), U1.39 (PB3)
BK3: SW16.1 (A), U1.29 (PA8)
BK4: SW17.1 (A), U1.30 (PA9)
DOWN: SW2.1 (A), U1.25 (PB12)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, J1.4 (GND), J1.5 (Shield), P1.3, SW1.2 (B), SW2.2 (B), SW3.2 (B), SW4.2 (B), SW5.2 (B), SW6.2 (B), SW7.2 (B), SW8.2 (B), SW9.2 (B), SW10.2 (B), SW11.2 (B), SW12.2 (B), SW13.2 (B), SW14.2 (B), SW15.2 (B), SW16.2 (B), SW17.2 (B), U1.9 (VDDA), U1.24 (VDD_1), U1.36 (VDD_2), U1.44 (BOOT0), U1.48 (VDD_3), U2.1 (GND)
L: SW10.1 (A), U1.13 (PA3)
LEFT: SW3.1 (A), U1.28 (PB15)
R: SW11.1 (A), U1.12 (PA2)
RIGHT: SW4.1 (A), U1.19 (PB1)
RST: C5.1, R1.2, SW7.1 (A), U1.7 (RST)
SELECT: SW12.1 (A), U1.31 (PA10)
START: SW13.1 (A), U1.38 (PA15)
SWCLK: P1.1, U1.37 (PA14)
SWDIO: P1.2, U1.34 (PA13)
UP: SW1.1 (A), U1.27 (PB14)
USB_DM: J1.2 (D-), U1.32 (PA11)
USB_DP: J1.3 (D+), R2.2, U1.33 (PA12)
X: SW8.1 (A), U1.2 (PC13)
X1: C7.1, U1.5 (OSC_IN), Y1.2
X2: C6.1, U1.6 (OSC_OUT), Y1.1
Y: SW9.1 (A), U1.46 (PB9)

Notes on the sheet:
USB gamdpad for Blackberry Classic

Board: 2 copper layers, 65.0 x 35.1 mm, 31 parts (0 on the bottom side), 26 nets.

## KiCad design handmade01/main.kicad_pcb

Schematic: main.sch

Parts:
BAT1: BAT
C1: 10uF
C2, C3: 2.2uF
C4, C5, C6, C9, C10: 0.1uF
C7, C8: 2.2nF
C11, C12: 1uF
CON1, CON2: MicroSD
J1: JACK_TRS_6PINS
LS1: SPEAKER_R
LS2: SPEAKER_L
P1: VOLUMN
P4: USB_OTG
P6: UART_DEBUG
Q1: 1AM
R1, R2: 10K
R3, R5, R6, R7, R8, R9, R10, R11, R12, R13, R14, R15, R16, R17, R18, R19, R20, R21, R22, R23, R24, R25, R26, R27, R28, R29, R30: 4.7K
R4: 100K
SW1: Power
SW2: Reset
SW3: UP
SW4: Down
SW5: Left
SW6: Right
SW7: Select
SW8: Start
SW9: L
SW10: R
SW11: A
SW12: B
SW13: X
SW14: Y
U1: PCM5102A
U2: PAM8403
U3: IPS_2.4_240x320_ST7789V
U4: CM3354
U5: TPS71718

Connections:
+3.3V: C6.2, C9.2, CON1.4 (VDD), CON2.4 (VDD), R4.1, R5.1, R6.1, R7.1, R8.1, R9.1, R10.1, R11.1, R12.1, R13.1, R14.1, R15.1, R16.1, R17.1, R18.1, R19.1, R20.1, R21.1, R22.1, R23.1, R24.1, R25.1, R26.1, R27.1, R28.1, R29.2, R30.1, U1.1 (CPVDD), U1.8 (AVDD), U1.10 (DEMP), U1.12 (SCK), U1.20 (DVDD), U2.4 (PVDD), U2.6 (VDD), U2.13 (PVDD), U3.2 (VCI), U3.3 (IOVCC), U3.4 (IM2), U3.6 (IM0), U3.10 (SPI_RS), U3.11 (RD), U3.36 (LED_A), U4.5 (VDD_3V3A)
+5V: P4.1 (VBUS), U4.1 (VBAT)
A: R24.2, SW11.1, U4.54 (UART1_RX)
AUDIO_BCK: U1.13 (BCK), U4.74 (MCASP0_ACLKX)
AUDIO_DIN: U1.14 (DIN), U4.76 (MCASP0_AXR0)
AUDIO_LRCK: U1.15 (LRCK), U4.75 (MCASP0_FSX)
AUDIO_MUTE: U1.17 (XSMT), U4.79 (EHRPWM1A)
B: R26.2, SW12.1, U4.55 (UART1_TX)
BAT_+: BAT1.1 (+), C11.2, U4.8 (BAT_SENSE), U4.9 (BAT_CHARGE), U5.1 (IN), U5.2 (GND)
BAT_T: BAT1.3 (TS), U4.10 (BAT_TS)
DOWN: R12.2, SW4.1, U4.68 (ADC2)
GND: BAT1.2 (-), C1.2, C3.2, C4.2, C5.2, C6.1, C7.1, C8.1, C9.1, C10.2, C11.1, C12.1, CON1.6 (VSS), CON1.10 (SHIELD), CON2.6 (VSS), CON2.10 (SHIELD), J1.1 (S), J1.4 (SN), P4.4 (ID), P4.5 (GND), P4.6 (shield), P6.1, Q1.3 (E), SW1.2, SW2.2, SW3.2, SW4.2, SW5.2, SW6.2, SW7.2, SW8.2, SW9.2, SW10.2, SW11.2, SW12.2, SW13.2, SW14.2, U1.3 (CPGND), U1.11 (FLT), U1.16 (FMT), U1.19 (DGND), U2.2 (PGND), U2.9 (NC), U2.11 (GND), U2.15 (PGND), U3.1 (GND), U3.5 (IM1), U3.45 (GND), U4.15 (USB0_ID), U4.22 (GND), U4.66 (GND), U4.71 (GND), U4.77 (GND), U5.3 (EN)
INL: P1.4, U2.7 (INL)
INR: P1.3, U2.10 (INR)
L: R20.2, SW9.1, U4.36 (MII1_RX_ER)
LCD_CS: U3.8 (SPI_CS), U4.41 (MII1_REF_CLK)
LCD_DB0: U3.17 (DB0), U4.86 (LCD_DATA0)
LCD_DB1: U3.18 (DB1), U4.82 (LCD_DATA1)
LCD_DB2: U3.19 (DB2), U4.85 (LCD_DATA2)
LCD_DB3: U3.20 (DB3), U4.98 (LCD_DATA3)
LCD_DB4: U3.21 (DB4), U4.81 (LCD_DATA4)
LCD_DB5: U3.22 (DB5), U4.84 (LCD_DATA5)
LCD_DB6: U3.23 (DB6), U4.89 (LCD_DATA6)
LCD_DB7: U3.24 (DB7), U4.96 (LCD_DATA7)
LCD_DB8: U3.25 (DB8), U4.83 (LCD_DATA8)
LCD_DB9: U3.26 (DB9), U4.87 (LCD_DATA9)
LCD_DB10: U3.27 (DB10), U4.91 (LCD_DATA10)
LCD_DB11: U3.28 (DB11), U4.93 (LCD_DATA11)
LCD_DB12: U3.29 (DB12), U4.88 (LCD_DATA12)
LCD_DB13: U3.30 (DB13), U4.90 (LCD_DATA13)
LCD_DB14: U3.31 (DB14), U4.92 (LCD_DATA14)
LCD_DB15: U3.32 (DB15), U4.97 (LCD_DATA15)
LCD_ENABLE: U3.14 (ENABLE), U4.100 (LCD_EN)
LCD_HSYNC: U3.13 (HSYNC), U4.99 (LCD_HSYNC)
LCD_PCLK: U3.15 (PCLK), U4.94 (LCD_PCLK)
LCD_RESET: U3.7 (RESET), U4.23 (GPIO_19)
LCD_SCL: U3.9 (SPI_SCL), U4.40 (MII1_CRS)
LCD_SDI: U3.16 (SPI_SDA), U4.39 (MII1_RX_DV)
LCD_SDO: U3.35 (SPI_SDO), U4.38 (MII1_COL)
LCD_VSYNC: U3.12 (VSYNC), U4.95 (LCD_VSYNC)
LED_K: Q1.2 (C), U3.37 (LED_K1), U3.38 (LED_K2), U3.39 (LED_K3), U3.40 (LED_K4)
LED_PWM: R3.2, U4.80 (LED_PWM)
LEFT: R13.2, SW5.1, U4.69 (ADC1)
MUTE: J1.2 (T), R4.2, U2.5 (MUTE), U2.12 (SHND)
unnamed: C5.1, U2.8 (VREF)
unnamed: C2.2, U1.2 (CAPP)
unnamed: C2.1, U1.4 (CAPM)
unnamed: C3.1, U1.5 (VNEG)
unnamed: R1.1, U1.6 (OUTL)
unnamed: C10.1, U1.18 (LDOO)
unnamed: R2.1, U1.7 (OUTR)
unnamed: C1.1, C4.1, U1.9 (AGND)
unnamed: Q1.1 (B), R3.1
OUTL: C7.2, J1.5 (TN), P1.1, R1.2
OUTR: C8.2, J1.6 (RN), P1.2, R2.2
OUT_L+: LS2.1, U2.1 (+OUT_L)
OUT_L-: LS2.2, U2.3 (-OUT_L)
OUT_R+: LS1.1, U2.16 (+OUT_R)
OUT_R-: LS1.2, U2.14 (-OUT_R)
POWER: SW1.1, U4.11 (PWR_BTN)
R: R22.2, SW10.1, U4.37 (MII1_TX_EN)
RESET: SW2.1, U4.53 (RESET)
RIGHT: R14.2, SW6.1, U4.67 (ADC3)
RTC_+: C12.2, U4.6 (VDDS_RTC), U5.5 (OUT)
SD0_CD: CON1.9 (INSERT), R29.1, U4.48 (MMC0_CD)
SD0_CLK: CON1.5 (CLK), R7.2, U4.45 (SD_MMC0_CLK)
SD0_CMD: CON1.3 (CMD), R8.2, U4.44 (SD_MMC0_CMD)
SD0_DAT0: CON1.7 (DAT0), R11.2, U4.43 (SD_MMC0_DAT0)
SD0_DAT1: CON1.8 (DAT1), R9.2, U4.42 (SD_MMC0_DAT1)
SD0_DAT2: CON1.1 (DAT2), R6.2, U4.46 (SD_MMC0_DAT2)
SD0_DAT3: CON1.2 (DAT3/CD), R5.2, U4.47 (SD_MMC0_DAT3)
SD1_CD: CON2.9 (INSERT), R30.2, U4.61 (UART4_RX)
SD1_CLK: CON2.5 (CLK), R19.2, U4.25 (MII1_MDC)
SD1_CMD: CON2.3 (CMD), R21.2, U4.24 (MII1_MDIO)
SD1_DAT0: CON2.7 (DAT0), R25.2, U4.29 (MII_GTX_CLK)
SD1_DAT1: CON2.8 (DAT1), R23.2, U4.27 (MII1_RX_CLK)
SD1_DAT2: CON2.1 (DAT2), R17.2, U4.26 (MII1_RXD3)
SD1_DAT3: CON2.2 (DAT3/CD), R15.2, U4.33 (MII1_RXD2)
SELECT: R16.2, SW7.1, U4.72 (MCASP0_AXR1)
START: R18.2, SW8.1, U4.73 (MCASP0_AHCLKX)
UART_RX: P6.3, U4.58 (UART0_RX)
UART_TX: P6.2, U4.59 (UART0_TX)
UP: R10.2, SW3.1, U4.70 (ADC0)
USB_DM: P4.2 (D-), U4.21 (USB0_DM)
USB_DP: P4.3 (D+), U4.20 (USB0_DP)
X: R27.2, SW13.1, U4.56 (CAN0_RX)
Y: R28.2, SW14.1, U4.57 (CAN0_TX)

Notes on the sheet:
Handmade01

Board: 2 copper layers, 64.8 x 70.1 mm, 71 parts (10 on the bottom side), 87 nets.

## KiCad design a320/s6e63d6/main.kicad_pcb

Parts:
C1, C2, C3, C4, C5, C6, C9, C10, C11, C12, C13: 1uF/10V
C7, C8: 1uF/16V
C14, C15, C16: 100pF
C17: 1nF
R1, R2: 100K
R3: 98K
U1: TFT_37PIN
U2: C0283QGLD-T
U3: MCP1727
U4: MAX889

Connections:
3.3V: U1.6 (VCC), U1.32 (VCC), U1.33 (VCC), U2.3 (VCI), U2.20 (IOVCC), U2.54 (VCI), U3.1 (VIN), U3.2 (VIN), U3.3 (SHDN)
5V: C15.2, R1.2, R2.1, U2.1 (AR_VDD), U3.7 (ADJ), U3.8 (VOUT), U4.1 (IN), U4.6 (SHDN)
-5V: C16.1, R3.2, U2.2 (AR_VSS), U4.5 (OUT)
CS: U1.7 (CS), U2.47 (CSB)
DB0: U1.1 (DB0), U2.39 (DB1)
DB1: U1.2 (DB1), U2.38 (DB2)
DB2: U1.3 (DB2), U2.37 (DB3)
DB3: U1.4 (DB3), U2.36 (DB4)
DB4: U1.22 (DB4), U2.35 (DB5)
DB5: U1.35 (DB5), U2.34 (DB6)
DB6: U1.36 (DB6), U2.33 (DB7)
DB7: U1.37 (DB7), U2.32 (DB8)
DB8: U1.23 (DB10), U2.30 (DB10)
DB9: U1.24 (DB11), U2.29 (DB11)
DB10: U1.25 (DB12), U2.28 (DB12)
DB11: U1.26 (DB13), U2.27 (DB13)
DB12: U1.27 (DB14), U2.26 (DB14)
DB13: U1.28 (DB15), U2.25 (DB15)
DB14: U1.29 (DB16), U2.24 (DB16)
DB15: U1.30 (DB17), U2.23 (DB17)
GND: C1.2, C4.2, C7.2, C8.2, C10.2, C11.2, C12.2, C13.2, C15.1, C16.2, C17.2, U1.5 (GND), U1.34 (GND), U2.5 (GND), U2.19 (VGS), U2.21 (SPB), U2.22 (ID_MIB), U2.57 (GND), U3.4 (GND), U4.3 (GND), U4.8 (AGND)
unnamed: C13.1, U2.56 (VGL)
unnamed: C12.1, U2.55 (VGH)
unnamed: C11.1, U2.53 (VREG1OUT)
unnamed: C10.1, U2.52 (MVDD)
unnamed: C8.1, U2.16 (VLOUT2)
unnamed: C9.1, U2.17 (C21P)
unnamed: C7.1, U2.15 (VLOUT3)
unnamed: C6.2, U2.14 (C32M)
unnamed: C6.1, U2.13 (C32P)
unnamed: C5.1, U2.11 (C31P)
unnamed: C17.1, U3.6 (CDELAY)
unnamed: C14.1, U4.2 (CAP+)
unnamed: R2.2, R3.1, U4.7 (FB)
unnamed: C14.2, U4.4 (CAP-)
unnamed: R1.1, U3.5 (PWRGD)
unnamed: C2.2, U2.7 (C12P)
unnamed: C5.2, U2.12 (C31M)
unnamed: C4.1, U2.10 (VLOUT1)
unnamed: C3.2, U2.9 (C11P)
unnamed: C2.1, U2.6 (C12M)
unnamed: C9.2, U2.18 (C21M)
unnamed: C3.1, U2.8 (C11M)
unnamed: C1.1, U2.4 (VCI1)
RD: U1.10 (RD), U2.50 (E_RDB)
RS: U1.8 (RS), U2.49 (RS)
RST: U1.31 (RST), U2.51 (RESETB)
WR: U1.9 (WR), U2.48 (RW_WRB)

Notes on the sheet:
Dingoo A320 OLED Screen (Panel:C0283QGLD, Driver:S6E63D6)

Board: 2 copper layers, 63.6 x 48.5 mm, 24 parts (0 on the bottom side), 48 nets.

## KiCad design stc15w204s/gpio/main.kicad_pcb

Parts:
C1: 10uF
D1, D2: LED
P1: CONN_5
R1, R2, R3, R4: 1K
SW1, SW2: SW_PUSH
U1: STC15W204

Connections:
GND: C1.2, P1.5, SW1.2, SW2.2, U1.4 (GND)
IN1: R3.2, SW1.1, U1.1 (P5.4,RST,MCLK0,CMP+)
IN2: R4.2, SW2.1, U1.8 (P3.3,INT1)
MCU_RX: P1.3, U1.5 (P3.0,RxD,INT4,T2CLK0)
MCU_TX: P1.2, U1.6 (P3.1,TxD,T2)
unnamed: D2.1 (A), R2.2
unnamed: D1.1 (A), R1.2
OUT1: D2.2 (K), U1.3 (P5.5,CMP-)
OUT2: D1.2 (K), U1.7 (P3.2,INT0)
VCC: C1.1, P1.1, R1.1, R2.1, R3.1, R4.1, U1.2 (VCC)

Notes on the sheet:
https://github.com/steward-fu/gh_stc15_gpio.git

Board: 2 copper layers, 16.5 x 15.2 mm, 11 parts (0 on the bottom side), 10 nets.

## KiCad design led/led.kicad_pcb

Parts:
D1: LED
K1: CONN_3
R1: R

Connections:
unnamed: K1.1, R1.1
unnamed: D1.1 (A), R1.2
unnamed: D1.2 (K), K1.3

Board: 2 copper layers, 52.1 x 26.7 mm, 3 parts (0 on the bottom side), 3 nets.

## Commit log

2008-12-31 20090101
2016-03-21 20160321
2016-03-25 20160325
2016-04-12 20160412
2016-04-12 20160413
2016-04-15 20160415
2016-04-20 20160420
2016-04-28 20160428
2016-04-29 20160429
2016-04-30 20160501
2016-12-01 20161201
2016-12-05 20161205
2016-12-06 20161206
2016-12-07 20161207
2017-01-20 20170120
2017-05-03 20170503
2017-08-24 20170824
2017-10-27 20171027
2017-10-30 20171030
2017-11-01 20171101
2017-11-06 20171106
2017-11-09 20171109
2017-11-12 20171112
2017-11-14 20171114
2017-11-15 20171115
2017-11-21 20171121
2017-11-29 20171129
2017-11-30 20171130
2017-12-01 20171201
2017-12-04 20171204
2017-12-05 20171205
2017-12-07 20171207
2017-12-08 20171208
2017-12-09 20171209
2017-12-11 20171211
2017-12-12 20171212
2017-12-13 20171213
2017-12-14 20171214
2017-12-15 20171215
2017-12-16 20171216
2017-12-16 20171217
2017-12-18 20171218
2017-12-19 20171219
2017-12-20 20171220
2017-12-23 20171223
